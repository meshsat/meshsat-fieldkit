# Repository meshsat/meshsat-fieldkit (continued)

## KiCad design v2/ecad/pcb-b-compute-b19/routed/pcb-b-compute-preroute.kicad_pcb

Schematic: pcb-b-compute.kicad_sch, MeshSat Field Kit carrier - PCB-B COMPUTE

Parts:
BT1: CR2032 holder Keystone 3034: VBAT for the three m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; BatteryHolder_Keystone_3034_1x20mm
C1, C2, C101, C102, C103, C104, C201, C202, C203, C204, C301, C302, C303, C304: 100u 10V; C_1206_3216Metric
C3, C10, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C29, C30, C31, C32, C36, C37, C38, C40, C44, C47, C49, C51, C54, C55, C57, C60, C62, C65, C66, C67, C68, C69, C70, C71, C110, C111, C118, C128, C133, C135, C136, C137, C138, C139, C140, C141, C142, C143, C144, C145, C146, C150, C158, C166, C167, C168, C169, C170, C171, C172, C173, C192, C194, C210, C211, C218, C228, C233, C235, C236, C237, C238, C239, C240, C241, C242, C243, C244, C245, C246, C250, C258, C266, C267, C268, C269, C270, C271, C272, C273, C286, C289, C292, C294, C310, C311, C318, C328, C333, C335, C336, C337, C338, C339, C340, C341, C342, C343, C344, C345, C346, C350, C358, C366, C367, C368, C369, C370, C371, C372, C373, C392, C394, C402, C403, C404, C405, C406, C409, C422, C423, C424, C425, C426, C429, C442, C443, C444, C445, C446, C449, C470, C471, C472, C473, C474, C475, C476, C477, C478, C479, C480: 100n; C_0603_1608Metric
C4, C7, C16, C27, C28, C39, C41, C46, C53, C64, C105, C106, C107, C108, C109, C125, C130, C147, C148, C174, C205, C206, C207, C208, C209, C225, C230, C247, C248, C274, C305, C306, C307, C308, C309, C325, C330, C347, C348, C374, C401, C421, C441: 10u; C_0805_2012Metric
C5, C6, C8, C9, C58, C63, C126, C127, C131, C132, C149, C157, C226, C227, C231, C232, C249, C257, C326, C327, C331, C332, C349, C357: 22u 6.3V; C_0805_2012Metric
C11, C56, C61, C129, C134, C229, C234, C329, C334, C481, C482, C483: 10n; C_0603_1608Metric
C12, C13, C163, C193, C263, C293, C363, C393, C400, C420, C440: 1u; C_0603_1608Metric
C14, C15, C164, C165, C264, C265, C364, C365, C410, C411, C430, C431, C450, C451: 18p; C_0402_1005Metric
C33: 1n 2kV; C_1812_4532Metric
C34: 100n 100V; C_0805_2012Metric; LCSC C106243
C35: 10u 100V; C_1210_3225Metric; LCSC C576517
C42: 47p; C_0402_1005Metric
C43, C48, C50, C59: 4.7u; C_0805_2012Metric
C45, C52: 1n; C_0603_1608Metric
C112, C113, C114, C115, C116, C119, C120, C121, C122, C123, C212, C213, C214, C215, C216, C219, C220, C221, C222, C223, C312, C313, C314, C315, C316, C319, C320, C321, C322, C323: 22u 10V X7R 1210; C_1210_3225Metric
C117, C124, C217, C224, C317, C324: 3.3n; C_0603_1608Metric
C151, C152, C251, C252, C351, C352: 220n 16V (PCIe AC coupling, CM5 datasheet 2.3.1); C_0402_1005Metric
C159, C160, C161, C162, C175, C176, C177, C178, C179, C180, C181, C182, C259, C260, C275, C276, C277, C278, C279, C280, C281, C282, C359, C360, C375, C376, C377, C378, C379, C380, C381, C382: 100n; C_0402_1005Metric
C287, C288, C290, C291: 33p; C_0402_1005Metric
C407, C408, C427, C428, C447, C448: 2.2u; C_0603_1608Metric
C460, C461, C506, C507: 4.7n; C_0603_1608Metric
C500, C501, C502, C503, C504, C505: 22p; C_0402_1005Metric
D1: SMBJ5.0A; D_SMB
D2: SMBJ58A; D_SMB; LCSC C135085
D101, D201, D301: SMBJ6.0A (6.0 V standoff on the 5.1 V slot rail); D_SMB; LCSC C83270
F1: 2A hold 1812; Fuse_1812_4532Metric
F2, F3: 0.5A hold 1812; Fuse_1812_4532Metric
J_5V_DEV: JST-VH socket, 10 A: USB device rail from A22 J_5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; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; LCSC C274411
J_5V_S1: JST-VH socket, 10 A: 5 V slot rail S1 from A22 J_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; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; LCSC C274411
J_5V_S2: JST-VH socket, 10 A: 5 V slot rail S2 from A22 J_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; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; LCSC C274411
J_5V_S3: JST-VH socket, 10 A: 5 V slot rail S3 from A22 J_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; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; LCSC C274411
J_54V: JST-VH socket, 10 A: 54 V PoE feed from A22 J_54V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; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; LCSC C274411
J_AB1: A-B interconnect (IDC 2x13, underside, mates A22'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; IDC-Header_2x13_P2.54mm_Vertical_NarrowPad
J_AB2: A-B wall-port ribbon (IDC 2x5): the wall USB pair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; IDC-Header_2x05_P2.54mm_Vertical_NarrowPad
J_CAM: camera lead (USB 2.0, bank 1 hub, port 3): 5V D- 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; PinHeader_1x04_P2.54mm_Vertical
J_DBG1: console UART0 and the module I2C of S1 (3.3 V, be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; PinHeader_1x05_P2.54mm_Vertical
J_DBG2: console UART0 and the module I2C of S2 (3.3 V, be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; PinHeader_1x05_P2.54mm_Vertical
J_DBG3: console UART0 and the module I2C of S3 (3.3 V, be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; PinHeader_1x05_P2.54mm_Vertical
J_ETH: RJ45 jack (Amphenol RJHSE5380): patch lead to the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; RJ45_Amphenol_RJHSE5380
J_FAN1: IP68 cooler fan of S1 (JST-SH 1.0): 5V GND TACHO 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; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical; LCSC C160390
J_FAN2: IP68 cooler fan of S2 (JST-SH 1.0): 5V GND TACHO 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; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical; LCSC C160390
J_FAN3: IP68 cooler fan of S3 (JST-SH 1.0): 5V GND TACHO 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; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical; LCSC C160390
J_FLASH1, J_FLASH2, J_FLASH3: USB-C 2.0 receptacle; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J_GNSS1: U.FL socket: pigtail to A22's GNSS jack J_RF4; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C88373
J_GNSS2: LG290P UART2 (bench): GND TX RX; PinHeader_1x03_P2.54mm_Vertical
J_HDMI: HDMI type A receptacle (Molex 208658-1001): cable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; HDMI_A_Molex_208658-1001_Horizontal; LCSC C916313
J_LIME: USB 3.0 type A receptacle (Wuerth 692122030100 la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; USB3_A_Receptacle_Wuerth_692122030100; LCSC C5355286
J_LORA1: U.FL socket: pigtail to A22's LoRa jack J_RF11; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C88373
J_M2C1, J_M2C3: M.2 E-key 2230 socket, TE 2199230-4, M2.5 standof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; M2_E-Key_Socket_2230; LCSC C2977809
J_M2C2: M.2 B-key 3052 socket, TE 1-2199119-5, M2.5 stand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; M2_B-Key_Socket_3052; LCSC C574849
J_M2N1, J_M2N2, J_M2N3: M.2 M-key 2242 socket, Amphenol MDT420M02001, M2.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; M2_M-Key_Socket_2242; LCSC C2927698
J_PANEL: panel ribbon to PCB-C C7 (IDC 2x13): the RP2040 p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; IDC-Header_2x13_P2.54mm_Vertical_NarrowPad
J_QMX: QMX USB lead (bank 2 hub, port 4): VBUS D- D+ GND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; PinHeader_1x04_P2.54mm_Vertical
J_RB9704: RockBLOCK 9704 16-pin (IDC 2x8) on the Ground Con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; IDC-Header_2x08_P2.54mm_Vertical_NarrowPad
J_RPIBOOT1: nRPIBOOT jumper S1: fit to flash the eMMC over J_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; PinHeader_1x02_P2.54mm_Vertical
J_RPIBOOT2: nRPIBOOT jumper S2: fit to flash the eMMC over J_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; PinHeader_1x02_P2.54mm_Vertical
J_RPIBOOT3: nRPIBOOT jumper S3: fit to flash the eMMC over J_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; PinHeader_1x02_P2.54mm_Vertical
J_SIM1: nano-SIM push-push GCT SIM8060 (SIM 1); nanoSIM_GCT_SIM8060-6-0-14-00; LCSC C6296715
J_SIM2: nano-SIM push-push GCT SIM8060 (SIM 2); nanoSIM_GCT_SIM8060-6-0-14-00; LCSC C6296715
J_SPI3: SPI0 breakout of S3 (2x5): 3V3 GND MISO MOSI SCLK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; PinHeader_2x05_P2.54mm_Vertical
J_W1A, J_W1B: U.FL: MHF4 pigtail from the slot 1 WiFi card, cha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; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C434808
J_W3A, J_W3B: U.FL: MHF4 pigtail from the slot 3 WiFi card, cha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; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C434808
J_WOA: U.FL: pigtail to A22's P2P jack, chain A; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C434808
J_WOB: U.FL: pigtail to A22's P2P jack, chain B; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C434808
J_ZBDBG1: CC2652P cJTAG ZBA (bench): 3V3 GND TMSC TCKC RESET; PinHeader_1x05_P2.54mm_Vertical
J_ZBDBG2: CC2652P cJTAG ZBB (bench): 3V3 GND TMSC TCKC RESET; PinHeader_1x05_P2.54mm_Vertical
L1: 4.7uH XAL4030-472ME; L_Coilcraft_XAL4020-XXX
L2, L103, L104, L203, L204, L303, L304: 2.2uH XAL4020-222ME; L_Coilcraft_XAL4020-XXX
L3: 27nH 0402 (antenna bias tee); L_0402_1005Metric; LCSC C12669
L101, L102, L201, L202, L301, L302: 3.3uH XAL6030-332ME; L_Coilcraft_XAL6060-XXX
LED1: green Ethernet port 1 link; LED_0603_1608Metric; LCSC C12624
LED2: green Ethernet port 2 link; LED_0603_1608Metric; LCSC C12624
LED3: green Ethernet port 3 link; LED_0603_1608Metric; LCSC C12624
LED4: green Ethernet port 4 link; LED_0603_1608Metric; LCSC C12624
LED6: red ZBA (DIO_7); LED_0603_1608Metric; LCSC C2286
LED7: green ZBA (DIO_8); LED_0603_1608Metric; LCSC C12624
LED8: red ZBB (DIO_7); LED_0603_1608Metric; LCSC C2286
LED9: green ZBB (DIO_8); LED_0603_1608Metric; LCSC C12624
LED11: green 5 V S1; LED_0603_1608Metric; LCSC C12624
LED12, LED22, LED32: green NVMe link (PORTSTATUS0); LED_0603_1608Metric; LCSC C12624
LED13, LED23, LED33: green card link (PORTSTATUS1); LED_0603_1608Metric; LCSC C12624
LED14, LED24, LED34: amber NVMe activity; LED_0603_1608Metric; LCSC C2287
LED15: blue WiFi link; LED_0603_1608Metric; LCSC C2288
LED16, LED26, LED36: green ACT (LED_nACT sinks); LED_0603_1608Metric; LCSC C12624
LED17, LED27, LED37: red PWR; LED_0603_1608Metric; LCSC C2286
LED21: green 5 V S2; LED_0603_1608Metric; LCSC C12624
LED25: amber 5G network; LED_0603_1608Metric; LCSC C2287
LED31: green 5 V S3; LED_0603_1608Metric; LCSC C12624
LED35: blue WiFi link, card 2; LED_0603_1608Metric; LCSC C2288
LED40: green IOCTRL A alive; LED_0603_1608Metric; LCSC C12624
LED41: green IOCTRL B alive; LED_0603_1608Metric; LCSC C12624
LED42: green IOCTRL C alive; LED_0603_1608Metric; LCSC C12624
Q1: CSD19532Q5B 100 V N-FET (4.6 mOhm at VGS 6 V, Pow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; PowerPAK_SO-8_Single; LCSC C473333
Q2: 2N7002 expander -> switch reset; SOT-23; LCSC C8545
Q3, Q4, Q5: 2N7002: a voted majority pulls the bank's hub int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; SOT-23; LCSC C8545
Q10: 2N7002: the changeover's complement, so a voted W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; SOT-23; LCSC C8545
Q101, Q201, Q301: BC857: LED_nPWR must be buffered (datasheet Table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; SOT-23
Q102, Q103, Q104, Q105, Q202, Q203, Q204, Q205, Q302, Q303, Q304, Q305: 2N7002; SOT-23; LCSC C8545
Q106, Q206, Q306: 2N7002 EMCON -> W_DISABLE1#; SOT-23; LCSC C8545
Q207: 2N7002 expander -> FULL_CARD_POWER_OFF#; SOT-23; LCSC C8545
Q208: 2N7002 expander -> RESET#; SOT-23; LCSC C8545
R1, R103, R108, R113, R115, R144, R203, R208, R213, R215, R244, R303, R308, R313, R315, R344: 10k 1%; R_0603_1608Metric
R2: 20.0k 1%; R_0603_1608Metric
R3: 6.04k 1% (ISET); R_0603_1608Metric
R4, R11, R14, R21, R22, R25, R28, R29, R30, R31, R37, R41, R42, R44, R47, R56, R63, R64, R75, R76, R87, R88, R132, R133, R134, R135, R137, R138, R141, R145, R146, R149, R151, R154, R155, R156, R157, R158, R232, R233, R234, R235, R237, R238, R240, R241, R245, R246, R249, R251, R254, R255, R256, R257, R258, R332, R333, R334, R335, R337, R338, R341, R345, R346, R349, R351, R354, R355, R356, R357, R358, R474, R475, R476, R510: 10k; R_0603_1608Metric
R5, R6, R7, R8, R24, R26, R27, R32, R33, R34, R35, R40, R65, R77, R89, R101, R129, R130, R131, R136, R139, R148, R150, R201, R229, R230, R231, R236, R239, R248, R250, R301, R329, R330, R331, R336, R339, R348, R350: 1k; R_0603_1608Metric
R9, R10: 75; R_0603_1608Metric
R12: 0.25R 1% 2512; R_2512_6332Metric
R13: 0R 2512 (POE_P link); R_2512_6332Metric
R15, R16, R48, R49, R50, R51, R52, R53, R58, R59, R60, R61, R62, R106, R111, R112, R160, R161, R206, R211, R212, R260, R261, R306, R311, R312, R360, R361, R477, R478, R479, R480, R481, R482, R483, R484, R485, R486, R487, R488, R489, R490, R491, R492, R493, R494, R495, R496, R497, R498, R499, R500: 100k; R_0603_1608Metric
R17, R18, R54, R55: 2.2k; R_0603_1608Metric
R19: 15k; R_0603_1608Metric
R20, R105, R110, R205, R210, R305, R310: 22k; R_0603_1608Metric
R23: 10R; R_0603_1608Metric
R36, R43: 301R 1% (ILM: 3.0 A); R_0603_1608Metric
R38, R45: 100k 1%; R_0603_1608Metric
R39, R46: 10k 1% (OVLO); R_0603_1608Metric
R57: 1k (strap [LED4_1, LED3_1] = 01: I2C management, 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; R_0603_1608Metric
R102, R107, R202, R207, R302, R307: 31.6k 1%; R_0603_1608Metric
R104, R109, R204, R209, R304, R309: 68k (RT: 500 kHz); R_0603_1608Metric
R114, R214, R314: 40.2k 1%; R_0603_1608Metric
R116, R216, R316: 26.7k 1%; R_0603_1608Metric
R117, R217, R317: 475 1% (IREF); R_0603_1608Metric
R118, R218, R318: 1.43k 1% (REXT); R_0603_1608Metric
R119, R120, R121, R123, R125, R126, R152, R153, R219, R220, R221, R223, R225, R226, R252, R253, R319, R320, R321, R323, R325, R326, R352, R353: 5.1k; R_0603_1608Metric
R122, R124, R128, R222, R224, R228, R322, R324, R328: 330; R_0603_1608Metric
R127, R227, R327: 4.7k; R_0603_1608Metric
R142, R242, R342: 9.53k 1%; R_0603_1608Metric
R143, R243, R343: 90.9k 1%; R_0603_1608Metric
R147, R247, R347: 1M; R_0603_1608Metric
R470, R471, R472, R473, R504, R505, R506, R507: 60R4 1%; R_0603_1608Metric
T1: Pulse H5007NL 1000BASE-T magnetics (switch port 4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; Pulse_H5007NL; LCSC C6384935
TP2: +5V_DEV; TestPoint_Pad_D1.5mm
TP3: +3V3_DEV; TestPoint_Pad_D1.5mm
TP4: +1V2_KSZ; TestPoint_Pad_D1.5mm
TP5: +2V5_KSZ; TestPoint_Pad_D1.5mm
TP6: VBAT; TestPoint_Pad_D1.5mm
TP7: EMCON_HW; TestPoint_Pad_D1.5mm
TP8: ZEROIZE_HW; TestPoint_Pad_D1.5mm
TP9: GNSS_PPS; TestPoint_Pad_D1.5mm
TP10: SDA; TestPoint_Pad_D1.5mm
TP11: SCL; TestPoint_Pad_D1.5mm
TP12: +54V_POE; TestPoint_Pad_D1.5mm
TP13: POE_DRAIN; TestPoint_Pad_D1.5mm
TP14: +5V_LIME; TestPoint_Pad_D1.5mm
TP15: +5V_RB; TestPoint_Pad_D1.5mm
TP16: +5V_LORA; TestPoint_Pad_D1.5mm
TP17: +3V3_ZB; TestPoint_Pad_D1.5mm
TP18: HDMI_SEL1; TestPoint_Pad_D1.5mm
TP19: HDMI_SEL2; TestPoint_Pad_D1.5mm
TP20: +3V3_S1A; TestPoint_Pad_D1.5mm
TP21: +3V3_S1B; TestPoint_Pad_D1.5mm
TP22: +1V0_S1; TestPoint_Pad_D1.5mm
TP23: +1V1_S1; TestPoint_Pad_D1.5mm
TP24: +3V3_S2A; TestPoint_Pad_D1.5mm
TP25: +3V3_S2B; TestPoint_Pad_D1.5mm
TP26: +1V0_S2; TestPoint_Pad_D1.5mm
TP27: +1V1_S2; TestPoint_Pad_D1.5mm
TP28: +3V3_S3A; TestPoint_Pad_D1.5mm
TP29: +3V3_S3B; TestPoint_Pad_D1.5mm
TP30: +1V0_S3; TestPoint_Pad_D1.5mm
TP31: +1V1_S3; TestPoint_Pad_D1.5mm
TP41: EXP_SPARE1; TestPoint_Pad_D1.5mm
TP42: EXP_SPARE2; TestPoint_Pad_D1.5mm
TP43: EXP_SPARE3; TestPoint_Pad_D1.5mm
TP44: EXP_SPARE4; TestPoint_Pad_D1.5mm
TP45: EXP_SPARE5; TestPoint_Pad_D1.5mm
TP46: EXP_SPARE6; TestPoint_Pad_D1.5mm
TP47: EXP_SPARE7; TestPoint_Pad_D1.5mm
TP48: EXP_SPARE8; TestPoint_Pad_D1.5mm
TP49: EXP_SPARE9; TestPoint_Pad_D1.5mm
TP50: EXP_SPARE10; TestPoint_Pad_D1.5mm
TP51: EXP_SPARE11; TestPoint_Pad_D1.5mm
U1: Microchip KSZ9897RTXI seven-port Gigabit switch: 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; TQFP-128_14x14mm_P0.4mm_EP10.0; LCSC C638299
U3: TI TS3DV642A0RUAR HDMI 2:1 switch (HDMI1 / HDMI2 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; WQFN-42-1EP_3.5x9mm_P0.5mm_EP2.05x7.55mm; LCSC C157482
U4: TI TS3DV642A0RUAR HDMI 2:1 switch (HDMIM / HDMI3 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; WQFN-42-1EP_3.5x9mm_P0.5mm_EP2.05x7.55mm; LCSC C157482
U5: TI TPS23861PWR PoE PSE controller, port 1 to the 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; TSSOP-28_4.4x9.7mm_P0.65mm; LCSC C93245
U6: PCA9555PW 0x20: outputs (switch reset, rail enabl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; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C2864778
U7: PCA9555PW 0x25: inputs (faults, RockBLOCK status)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; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C2864778
U8: ATECC608B-SSHDA-T secure element (I2C 0x60): keys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; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C1518769
U9: DS3231MZ+ holdover clock (I2C 0x68), CR2032 backed; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C9866
U10: TMP117AIDRVR board temperature under the coolers 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; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; LCSC C699536
U11: Quectel LG290P03AAMD GNSS RTK module: UART1 to th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; Quectel_LG290P; LCSC C29781241
U12: Ebyte E22-900M30S 1 W LoRa (SX1262) on S3 SPI0 CE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; Ebyte_E22-900M30S; LCSC C411294
U13: Ebyte E72-2G4M20S1E CC2652P (Zigbee coordinator):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; Ebyte_E72-2G4M20S1E
U14: Ebyte E72-2G4M20S1E CC2652P (OpenThread RCP for M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; Ebyte_E72-2G4M20S1E
U15: CP2102N-A02-GQFN28 USB-UART bridge (GNSS); QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C964632
U16: CP2102N-A02-GQFN28 USB-UART bridge (ZBA); QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C964632
U17: CP2102N-A02-GQFN28 USB-UART bridge (ZBB); QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C964632
U18: CP2102N-A02-GQFN28 USB-UART bridge (RB); QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C964632
U19: SN74LVC08APWR quad AND: LimeSDR (hub port power A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; TSSOP-14_4.4x5mm_P0.65mm; LCSC C465737
U20: SN74LVC08APWR quad AND: E72 radios (EMCON AND sof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; TSSOP-14_4.4x5mm_P0.65mm; LCSC C465737
U21, U22: TPS22810DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U23: TPS259631DDAR eFuse +5V_DEV -> +5V_LIME (301R 1% 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; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2155778
U24: TPS259631DDAR eFuse +5V_DEV -> +5V_RB (301R 1% (I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; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2155778
U25: AP63203WU-7 3.3 V 2 A buck: the shared logic (+3V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; TSOT-23-6; LCSC C780769
U26: TPS62933DRLR buck 1.2 V Ethernet switch core; SOT-583-8; LCSC C3200405
U27: AP2112K-2.5 LDO: the switch's 2.5 V analog rail; SOT-23-5; LCSC C176945
U28: TPS2065CDBV; SOT-23-5
U29, U33, U34, U35, U37, U107, U207, U307: USBLC6-2SC6; SOT-23-6; LCSC C7519
U30A: Amphenol 10164227-1004A1RLF receptacle A, slot S1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; CM5_Conn_A_10164227; LCSC C7435219
U30B: Amphenol 10164227-1004A1RLF receptacle B, slot S1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; CM5_Conn_B_10164227; LCSC C7435219
U31A: Amphenol 10164227-1004A1RLF receptacle A, slot S2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; CM5_Conn_A_10164227; LCSC C7435219
U31B: Amphenol 10164227-1004A1RLF receptacle B, slot S2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; CM5_Conn_B_10164227; LCSC C7435219
U32A: Amphenol 10164227-1004A1RLF receptacle A, slot S3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; CM5_Conn_A_10164227; LCSC C7435219
U32B: Amphenol 10164227-1004A1RLF receptacle B, slot S3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; CM5_Conn_B_10164227; LCSC C7435219
U40, U50, U60: AP2112K-3.3 LDO: the private 3.3 V of controller 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; SOT-23-5
U41: STM32H753VITx I/O supervisor A: 2-of-3 quorum on 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; LQFP-100_14x14mm_P0.5mm; LCSC C114409
U42: SWD pads, controller A: 3V3 SWDIO SWCLK NRST GND; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
U43, U44: TCAN334D CAN-FD transceiver, controller A on hear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; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2871143
U51: STM32H753VITx I/O supervisor B: 2-of-3 quorum on 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; LQFP-100_14x14mm_P0.5mm; LCSC C114409
U52: SWD pads, controller B: 3V3 SWDIO SWCLK NRST GND; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
U53, U54: TCAN334D CAN-FD transceiver, controller B on hear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; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2871143
U61: STM32H753VITx I/O supervisor C: 2-of-3 quorum on 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; LQFP-100_14x14mm_P0.5mm; LCSC C114409
U62: SWD pads, controller C: 3V3 SWDIO SWCLK NRST GND; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
U63, U64: TCAN334D CAN-FD transceiver, controller C on hear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; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2871143
U70, U71, U72, U73, U74, U75: SN74LVC08APWR quad 2-input AND: the 2-of-3 majori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; TSSOP-14_4.4x5mm_P0.65mm; LCSC C465737
U76, U77, U78, U79: SN74LVC32APWR quad 2-input OR: the 2-of-3 majorit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; TSSOP-14_4.4x5mm_P0.65mm; LCSC C352974
U80: 74LVC86APW quad exclusive-or: break-before-make o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; TSSOP-14_4.4x5mm_P0.65mm; LCSC C350562
U82: SKY13351-378LF SPDT antenna changeover, chain A: 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; Skyworks_SKY13351_MLPD-6_1x1mm; LCSC C129189
U83: SKY13351-378LF SPDT antenna changeover, chain B: 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; Skyworks_SKY13351_MLPD-6_1x1mm; LCSC C129189
U101: Diodes PI7C9X2G404SL PCIe 2.0 switch, slot S1: up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; LQFP-128_14x14mm_P0.4mm_EP6.0; LCSC C500767
U102: TI TUSB8041IRGCR four-port USB 3.0 hub, slot S1 (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; QFN-64-1EP_9x9mm_P0.5mm_EP4.7x4.7mm; LCSC C544686
U103: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S1A; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U104: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S1B; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U105: TPS62933DRLR buck 1.0 V PCIe switch core S1; SOT-583-8; LCSC C3200405
U106: TPS62933DRLR buck 1.1 V hub core S1 (on the devic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; SOT-583-8; LCSC C3200405
U109: TI TMUXHS4212 SuperSpeed 2:1 host select, bank 1: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; Texas_RKS0020A_VQFN-20_2.5x4.5mm; LCSC C3656912
U110: TI TS3USB221A USB2 2:1 host select, bank 1: port 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; Texas_RSE0010A_UQFN-10_1.5x2mm; LCSC C128396
U201: Diodes PI7C9X2G404SL PCIe 2.0 switch, slot S2: up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; LQFP-128_14x14mm_P0.4mm_EP6.0; LCSC C500767
U202: TI TUSB8041IRGCR four-port USB 3.0 hub, slot S2 (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; QFN-64-1EP_9x9mm_P0.5mm_EP4.7x4.7mm; LCSC C544686
U203: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S2A; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U204: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S2B; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U205: TPS62933DRLR buck 1.0 V PCIe switch core S2; SOT-583-8; LCSC C3200405
U206: TPS62933DRLR buck 1.1 V hub core S2 (on the devic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; SOT-583-8; LCSC C3200405
U209: TI TMUXHS4212 SuperSpeed 2:1 host select, bank 2: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; Texas_RKS0020A_VQFN-20_2.5x4.5mm; LCSC C3656912
U210: TI TS3USB221A USB2 2:1 host select, bank 2: port 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; Texas_RSE0010A_UQFN-10_1.5x2mm; LCSC C128396
U301: Diodes PI7C9X2G404SL PCIe 2.0 switch, slot S3: up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; LQFP-128_14x14mm_P0.4mm_EP6.0; LCSC C500767
U302: TI TUSB8041IRGCR four-port USB 3.0 hub, slot S3 (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; QFN-64-1EP_9x9mm_P0.5mm_EP4.7x4.7mm; LCSC C544686
U303: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S3A; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U304: AP64500SP-13 5 A buck, 3.3 V rail +3V3_S3B; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C2070920
U305: TPS62933DRLR buck 1.0 V PCIe switch core S3; SOT-583-8; LCSC C3200405
U306: TPS62933DRLR buck 1.1 V hub core S3 (on the devic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; SOT-583-8; LCSC C3200405
U309: TI TMUXHS4212 SuperSpeed 2:1 host select, bank 3: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; Texas_RKS0020A_VQFN-20_2.5x4.5mm; LCSC C3656912
U310: TI TS3USB221A USB2 2:1 host select, bank 3: port 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; Texas_RSE0010A_UQFN-10_1.5x2mm; LCSC C128396
Y1: 25 MHz 3225; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C164047
Y2, Y3, Y4: 25 MHz 3225 (CAN-FD bit timing needs a crystal, n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; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C164047
Y101, Y201, Y301: 24 MHz 3225; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections (part):
/5G_OFF: Q207.1 (G), R61.1, U6.10 (IO0_6)
/5G_PWROFF_n: J_M2C2.6 (~FULL_CARD_POWER_OFF), Q207.3 (D), R238.1
/5G_RESET: Q208.1 (G), R62.1, U6.11 (IO0_7)
/5G_RST_n: J_M2C2.67 (~RESET), Q208.3 (D), R240.1
/5G_W_DIS_n: J_M2C2.8 (~W_DISABLE1), Q206.2 (S), R237.1
/5G_nLED: J_M2C2.10 (GPIO_9/DAS/~DSS/~LED1), LED25.1 (K)
/+1V0_S1: C126.1, C127.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C148.1, L103.2, R113.1, TP22.1, U101.3 (VDDC), U101.13 (VDDCAUX), U101.14 (VDDCAUX), U101.23 (VDDC), U101.29 (VDDC), U101.31 (VDDC), U101.40 (VDDC), U101.55 (VDDC), U101.62 (VDDC), U101.65 (VDDC), U101.91 (VDDC), U101.99 (AVDD), U101.105 (AVDD), U101.108 (AVDD), U101.119 (AVDD), U101.125 (AVDD)
/+1V0_S2: C226.1, C227.1, C241.1, C242.1, C243.1, C244.1, C245.1, C246.1, C248.1, L203.2, R213.1, TP26.1, U201.3 (VDDC), U201.13 (VDDCAUX), U201.14 (VDDCAUX), U201.23 (VDDC), U201.29 (VDDC), U201.31 (VDDC), U201.40 (VDDC), U201.55 (VDDC), U201.62 (VDDC), U201.65 (VDDC), U201.91 (VDDC), U201.99 (AVDD), U201.105 (AVDD), U201.108 (AVDD), U201.119 (AVDD), U201.125 (AVDD)
/+1V0_S3: C326.1, C327.1, C341.1, C342.1, C343.1, C344.1, C345.1, C346.1, C348.1, L303.2, R313.1, TP30.1, U301.3 (VDDC), U301.13 (VDDCAUX), U301.14 (VDDCAUX), U301.23 (VDDC), U301.29 (VDDC), U301.31 (VDDC), U301.40 (VDDC), U301.55 (VDDC), U301.62 (VDDC), U301.65 (VDDC), U301.91 (VDDC), U301.99 (AVDD), U301.105 (AVDD), U301.108 (AVDD), U301.119 (AVDD), U301.125 (AVDD)
/+1V1_S1: C131.1, C132.1, C166.1, C167.1, C168.1, C169.1, C174.1, L104.2, R115.1, TP23.1, U102.5 (VDD), U102.8 (VDD), U102.13 (VDD), U102.21 (VDD), U102.28 (VDD), U102.31 (VDD), U102.51 (VDD), U102.57 (VDD)
/+1V1_S2: C231.1, C232.1, C266.1, C267.1, C268.1, C269.1, C274.1, L204.2, R215.1, TP27.1, U202.5 (VDD), U202.8 (VDD), U202.13 (VDD), U202.21 (VDD), U202.28 (VDD), U202.31 (VDD), U202.51 (VDD), U202.57 (VDD)
/+1V1_S3: C331.1, C332.1, C366.1, C367.1, C368.1, C369.1, C374.1, L304.2, R315.1, TP31.1, U302.5 (VDD), U302.8 (VDD), U302.13 (VDD), U302.21 (VDD), U302.28 (VDD), U302.31 (VDD), U302.51 (VDD), U302.57 (VDD)
/+1V2_KSZ: C8.1, C9.1, C18.1, C21.1, C24.1, C27.1, L2.2, R1.1, TP4.1, U1.3 (AVDDL), U1.11 (DVDDL), U1.14 (AVDDL), U1.19 (AVDDL), U1.23 (DVDDL), U1.30 (AVDDL), U1.36 (AVDDL), U1.41 (AVDDL), U1.45 (DVDDL), U1.56 (DVDDL), U1.74 (DVDDL), U1.87 (DVDDL), U1.104 (DVDDL), U1.110 (DVDDL), U1.114 (AVDDL), U1.119 (AVDDL), U1.124 (AVDDL)
/+1V8_CM1: U30A.88 (CM5_1.8V), U30A.90 (CM5_1.8V)
/+1V8_CM2: U31A.88 (CM5_1.8V), U31A.90 (CM5_1.8V)
/+1V8_CM3: U32A.88 (CM5_1.8V), U32A.90 (CM5_1.8V)
/+2V5_KSZ: C12.1, C19.1, C22.1, C25.1, C28.1, TP5.1, U1.10 (AVDDH), U1.22 (AVDDH), U1.33 (AVDDH), U1.44 (AVDDH), U1.111 (AVDDH), U1.122 (AVDDH), U1.128 (AVDDH), U27.5 (+2V5_KSZ)
/+3V3_CM1: C109.1, C110.1, Q101.2 (E), Q102.1 (G), Q103.1 (G), Q104.1 (G), Q105.1 (G), R111.1, R148.1, R151.2, R154.2, R155.2, R156.2, R157.2, U30A.78 (GPIO_VREF), U30A.84 (CM5_3.3V), U30A.86 (CM5_3.3V)
/+3V3_CM2: C209.1, C210.1, Q201.2 (E), Q202.1 (G), Q203.1 (G), Q204.1 (G), Q205.1 (G), R211.1, R248.1, R251.2, R254.2, R255.2, R256.2, R257.2, U31A.78 (GPIO_VREF), U31A.84 (CM5_3.3V), U31A.86 (CM5_3.3V)
/+3V3_CM3: C309.1, C310.1, Q301.2 (E), Q302.1 (G), Q303.1 (G), Q304.1 (G), Q305.1 (G), R311.1, R348.1, R351.2, R354.2, R355.2, R356.2, R357.2, U32A.78 (GPIO_VREF), U32A.84 (CM5_3.3V), U32A.86 (CM5_3.3V)
/+3V3_DEV: C5.1, C6.1, C13.1, C17.1, C20.1, C23.1, C26.1, C36.1, C37.1, C38.1, C40.1, C41.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C170.1, C171.1, C172.1, C173.1, C192.1, C193.1, C194.1, C270.1, C271.1, C272.1, C273.1, C292.1, C293.1, C294.1, C370.1, C371.1, C372.1, C373.1, C392.1, C393.1, C394.1, C470.1, C471.1, C472.1, C473.1, C474.1, C475.1, C476.1, C477.1, C478.1, C479.1, C480.1, L1.2, R4.2, R5.1, R6.1, R7.1, R8.1, R11.2, R14.2, R21.2, R37.2, R41.2, R42.2, R44.2, R47.2, R54.2, R55.2, R56.2, R141.2, R145.2, R146.2, R158.2, R241.2, R245.2, R246.2, R258.2, R341.2, R345.2, R346.2, R358.2, R510.2, TP3.1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
/+3V3_IOCA: C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, R63.2, R65.1, U40.5 (+3V3_IOCA), U41.6 (VBAT), U41.11 (VDD), U41.20 (VREF+), U41.21 (VDDA), U41.27 (VDD), U41.50 (VDD), U41.75 (VDD), U41.100 (VDD), U42.1 (+3V3_IOCA), U43.3 (+3V3_IOCA), U44.3 (+3V3_IOCA)
/+3V3_IOCB: C421.1, C422.1, C423.1, C424.1, C425.1, C426.1, R75.2, R77.1, U50.5 (+3V3_IOCB), U51.6 (VBAT), U51.11 (VDD), U51.20 (VREF+), U51.21 (VDDA), U51.27 (VDD), U51.50 (VDD), U51.75 (VDD), U51.100 (VDD), U52.1 (+3V3_IOCB), U53.3 (+3V3_IOCB), U54.3 (+3V3_IOCB)
/+3V3_IOCC: C441.1, C442.1, C443.1, C444.1, C445.1, C446.1, R87.2, R89.1, U60.5 (+3V3_IOCC), U61.6 (VBAT), U61.11 (VDD), U61.20 (VREF+), U61.21 (VDDA), U61.27 (VDD), U61.50 (VDD), U61.75 (VDD), U61.100 (VDD), U62.1 (+3V3_IOCC), U63.3 (+3V3_IOCC), U64.3 (+3V3_IOCC)
/+3V3_S1A: C114.1, C115.1, C116.1, C157.1, C158.1, J_M2C1.2 (3.3V), J_M2C1.4 (3.3V), J_M2C1.72 (3.3V), J_M2C1.74 (3.3V), L101.2, Q106.1 (G), R102.1, R134.2, R137.2, R138.2, R139.1, TP20.1
/+3V3_S1B: C121.1, C122.1, C123.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C147.1, C149.1, C150.1, J_M2N1.2 (3.3V), J_M2N1.4 (3.3V), J_M2N1.12 (3.3V), J_M2N1.14 (3.3V), J_M2N1.16 (3.3V), J_M2N1.18 (3.3V), J_M2N1.70 (3.3V), J_M2N1.72 (3.3V), J_M2N1.74 (3.3V), L102.2, R107.1, R119.2, R120.2, R121.2, R123.2, R125.2, R126.2, R130.1, R131.1, R132.2, R133.2, R136.1, TP21.1, U101.1 (VDDR), U101.8 (VDDR), U101.15 (VAUX), U101.49 (VDDR), U101.64 (VDDR), U101.79 (CVDDR), U101.82 (CVDDR), U101.84 (CVDDR), U101.96 (VDDR), U101.113 (AVDDH)
/+3V3_S2A: C214.1, C215.1, C216.1, C257.1, C258.1, J_M2C2.2 (3.3V), J_M2C2.4 (3.3V), J_M2C2.70 (3.3V), J_M2C2.72 (3.3V), J_M2C2.74 (3.3V), L201.2, Q206.1 (G), R202.1, R234.2, R237.2, R238.2, R239.1, R240.2, TP24.1
/+3V3_S2B: C221.1, C222.1, C223.1, C235.1, C236.1, C237.1, C238.1, C239.1, C240.1, C247.1, C249.1, C250.1, J_M2N2.2 (3.3V), J_M2N2.4 (3.3V), J_M2N2.12 (3.3V), J_M2N2.14 (3.3V), J_M2N2.16 (3.3V), J_M2N2.18 (3.3V), J_M2N2.70 (3.3V), J_M2N2.72 (3.3V), J_M2N2.74 (3.3V), L202.2, R207.1, R219.2, R220.2, R221.2, R223.2, R225.2, R226.2, R230.1, R231.1, R232.2, R233.2, R236.1, TP25.1, U201.1 (VDDR), U201.8 (VDDR), U201.15 (VAUX), U201.49 (VDDR), U201.64 (VDDR), U201.79 (CVDDR), U201.82 (CVDDR), U201.84 (CVDDR), U201.96 (VDDR), U201.113 (AVDDH)
/+3V3_S3A: C314.1, C315.1, C316.1, C357.1, C358.1, J_M2C3.2 (3.3V), J_M2C3.4 (3.3V), J_M2C3.72 (3.3V), J_M2C3.74 (3.3V), L301.2, Q306.1 (G), R302.1, R334.2, R337.2, R338.2, R339.1, TP28.1
/+3V3_S3B: C321.1, C322.1, C323.1, C335.1, C336.1, C337.1, C338.1, C339.1, C340.1, C347.1, C349.1, C350.1, J_M2N3.2 (3.3V), J_M2N3.4 (3.3V), J_M2N3.12 (3.3V), J_M2N3.14 (3.3V), J_M2N3.16 (3.3V), J_M2N3.18 (3.3V), J_M2N3.70 (3.3V), J_M2N3.72 (3.3V), J_M2N3.74 (3.3V), J_SPI3.1, L302.2, R25.2, R307.1, R319.2, R320.2, R321.2, R323.2, R325.2, R326.2, R330.1, R331.1, R332.2, R333.2, R336.1, TP29.1, U301.1 (VDDR), U301.8 (VDDR), U301.15 (VAUX), U301.49 (VDDR), U301.64 (VDDR), U301.79 (CVDDR), U301.82 (CVDDR), U301.84 (CVDDR), U301.96 (VDDR), U301.113 (AVDDH)
/+3V3_ZB: C53.1, C54.1, C55.1, J_ZBDBG1.1, J_ZBDBG2.1, R28.2, R29.2, R30.2, R31.2, TP17.1, U13.20 (+3V3_ZB), U14.20 (+3V3_ZB), U22.1 (VOUT)
/+5V_CAM: C64.1, J_CAM.1, U28.1 (OUT), U34.5 (VBUS)
/+5V_DEV: C1.1, C2.1, C4.1, C7.1, C57.1, C62.1, C130.1, C230.1, C330.1, C400.1, C420.1, C440.1, D1.1 (A1), F1.1, F2.1, F3.1, J_5V_DEV.1, R38.1, R45.1, R143.1, R243.1, R343.1, TP2.1, U15.7 (VREGIN), U15.8 (VBUS), U16.7 (VREGIN), U16.8 (VBUS), U17.7 (VREGIN), U17.8 (VBUS), U18.7 (VREGIN), U18.8 (VBUS), U21.6 (VIN), U23.4 (+5V_DEV), U24.4 (+5V_DEV), U25.2 (+5V_DEV), U25.3 (+5V_DEV), U26.2 (+5V_DEV), U26.3 (+5V_DEV), U28.5 (IN), U40.1 (+5V_DEV), U40.3 (+5V_DEV), U50.1 (+5V_DEV), U50.3 (+5V_DEV), U60.1 (+5V_DEV), U60.3 (+5V_DEV), U106.2 (+5V_DEV), U106.3 (+5V_DEV), U206.2 (+5V_DEV), U206.3 (+5V_DEV), U306.2 (+5V_DEV), U306.3 (+5V_DEV)
/+5V_HDMI: C39.1, F2.2, J_HDMI.18 (+5V), R17.2, R18.2
/+5V_LIME: C58.1, J_LIME.1 (VBUS), TP14.1, U23.5 (+5V_LIME), U33.5 (VBUS)
/+5V_LORA: C46.1, C47.1, TP16.1, U12.9 (VCC), U12.10 (VCC), U21.1 (VOUT)
/+5V_RB: C63.1, J_RB9704.15, TP15.1, U24.5 (+5V_RB)
/+5V_S1: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C112.1, C113.1, C119.1, C120.1, C125.1, D101.1 (A1), J_5V_S1.1, J_FAN1.1, R101.1, U30A.77 (5V), U30A.79 (5V), U30A.81 (5V), U30A.83 (5V), U30A.85 (5V), U30A.87 (5V), U103.2 (+5V_S1), U104.2 (+5V_S1), U105.3 (+5V_S1)
/+5V_S2: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C212.1, C213.1, C219.1, C220.1, C225.1, D201.1 (A1), J_5V_S2.1, J_FAN2.1, R201.1, U31A.77 (5V), U31A.79 (5V), U31A.81 (5V), U31A.83 (5V), U31A.85 (5V), U31A.87 (5V), U203.2 (+5V_S2), U204.2 (+5V_S2), U205.3 (+5V_S2)
/+5V_S3: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C312.1, C313.1, C319.1, C320.1, C325.1, D301.1 (A1), J_5V_S3.1, J_FAN3.1, R301.1, U32A.77 (5V), U32A.79 (5V), U32A.81 (5V), U32A.83 (5V), U32A.85 (5V), U32A.87 (5V), U303.2 (+5V_S3), U304.2 (+5V_S3), U305.3 (+5V_S3)
/+54V_POE: C34.1, C35.1, D2.1 (A1), J_54V.1, R13.1, TP12.1, U5.28 (VPWR)
/BANK1_UPD_N: U102.54 (USB_DM_UP), U110.7 (Dn)
/BANK1_UPD_P: U102.53 (USB_DP_UP), U110.8 (Dp)
/BANK1_UPRX_N: C160.1, U102.56 (USB_SSTXM_UP)
/BANK1_UPRX_P: C159.1, U102.55 (USB_SSTXP_UP)
/BANK1_UPTX_N: U102.59 (USB_SSRXM_UP), U109.4 (A0n)
/BANK1_UPTX_P: U102.58 (USB_SSRXP_UP), U109.3 (A0p)
/BANK2_UPD_N: U202.54 (USB_DM_UP), U210.7 (Dn)
/BANK2_UPD_P: U202.53 (USB_DP_UP), U210.8 (Dp)
/BANK2_UPRX_N: C260.1, U202.56 (USB_SSTXM_UP)
/BANK2_UPRX_P: C259.1, U202.55 (USB_SSTXP_UP)
/BANK2_UPTX_N: U202.59 (USB_SSRXM_UP), U209.4 (A0n)
/BANK2_UPTX_P: U202.58 (USB_SSRXP_UP), U209.3 (A0p)
/BANK3_UPD_N: U302.54 (USB_DM_UP), U310.7 (Dn)
/BANK3_UPD_P: U302.53 (USB_DP_UP), U310.8 (Dp)
/BANK3_UPRX_N: C360.1, U302.56 (USB_SSTXM_UP)
/BANK3_UPRX_P: C359.1, U302.55 (USB_SSTXP_UP)
/BANK3_UPTX_N: U302.59 (USB_SSRXM_UP), U309.4 (A0n)
/BANK3_UPTX_P: U302.58 (USB_SSRXP_UP), U309.3 (A0p)
/BOB: C33.1, R9.2, R10.2
/BOE1_n: R161.1, U80.3 (BOE1_n), U109.2 (OEn), U110.6 (OEn)
/BOE2_n: R261.1, U80.6 (BOE2_n), U209.2 (OEn), U210.6 (OEn)
/BOE3_n: R361.1, U80.8 (BOE3_n), U309.2 (OEn), U310.6 (OEn)
/BSEL1: R160.1, R474.1, U41.38 (PE8), U51.38 (PE8), U61.38 (PE8), U76.6 (BSEL1), U80.1 (BSEL1), U109.9 (SEL), U110.9 (S)
/BSEL1_D: C481.1, R474.2, U80.2 (BSEL1_D)
/BSEL2: R260.1, R475.1, U41.39 (PE9), U51.39 (PE9), U61.39 (PE9), U76.11 (BSEL2), U80.4 (BSEL2), U209.9 (SEL), U210.9 (S)
/BSEL2_D: C482.1, R475.2, U80.5 (BSEL2_D)
/BSEL3: R360.1, R476.1, U41.40 (PE10), U51.40 (PE10), U61.40 (PE10), U77.6 (BSEL3), U80.10 (BSEL3), U309.9 (SEL), U310.9 (S)
/BSEL3_D: C483.1, R476.2, U80.9 (BSEL3_D)
/BT_nDIS1: U6.16 (IO1_3), U30A.91 (BT_nDisable)
/BT_nDIS2: U6.17 (IO1_4), U31A.91 (BT_nDisable)
/BT_nDIS3: U6.18 (IO1_5), U32A.91 (BT_nDisable)
/CAM_DM: J_CAM.2, U34.3 (I/O2), U34.4 (I/O2), U102.18 (USB_DM_DN3)
/CAM_DP: J_CAM.3, U34.1 (I/O1), U34.6 (I/O1), U102.17 (USB_DP_DN3)
/CAM_EN: R48.1, U6.9 (IO0_5), U28.4 (EN)
/CAM_FLT: R47.1, U7.6 (IO0_2), U28.3 (~FLT)
/CANH_A: R470.1, R504.1, U43.7 (CANH_A), U53.7 (CANH_A), U63.7 (CANH_A)
/CANH_B: R472.1, R506.1, U44.7 (CANH_B), U54.7 (CANH_B), U64.7 (CANH_B)
/CANL_A: R471.2, R505.2, U43.6 (CANL_A), U53.6 (CANL_A), U63.6 (CANL_A)
/CANL_B: R473.2, R507.2, U44.6 (CANL_B), U54.6 (CANL_B), U64.6 (CANL_B)
/CANT2_A: C506.1, R504.2, R505.1
/CANT2_B: C507.1, R506.2, R507.1
/CANT_A: C460.1, R470.2, R471.1
/CANT_B: C461.1, R472.2, R473.1
/CARD1_CLKREQ_n: J_M2C1.53 (~CLKREQ0), R134.1
/CARD1_CLK_N: J_M2C1.49 (REFCLKn0), U101.77 (REFCLKO_N2)
/CARD1_CLK_P: J_M2C1.47 (REFCLKp0), U101.78 (REFCLKO_P2)
/CARD1_RX_N: J_M2C1.43 (PERn0), U101.107 (PETN2)
/CARD1_RX_P: J_M2C1.41 (PERp0), U101.106 (PETP2)
/CARD1_TX_N: J_M2C1.37 (PETn0), U101.103 (PERN2)
/CARD1_TX_P: J_M2C1.35 (PETp0), U101.102 (PERP2)
/CARD2_CLKREQ_n: J_M2C2.52 (~CLKREQ), R234.1
/CARD2_CLK_N: J_M2C2.53 (REFCLKn), U201.77 (REFCLKO_N2)
/CARD2_CLK_P: J_M2C2.55 (REFCLKp), U201.78 (REFCLKO_P2)
/CARD2_RX_N: J_M2C2.41 (PERn0/SATA-B+), U201.107 (PETN2)
/CARD2_RX_P: J_M2C2.43 (PERp0/SATA-B-), U201.106 (PETP2)
/CARD2_TX_N: J_M2C2.47 (PETn0/SATA-A-), U201.103 (PERN2)
/CARD2_TX_P: J_M2C2.49 (PETp0/SATA-A+), U201.102 (PERP2)
/CARD3_CLKREQ_n: J_M2C3.53 (~CLKREQ0), R334.1
/CARD3_CLK_N: J_M2C3.49 (REFCLKn0), U301.77 (REFCLKO_N2)
/CARD3_CLK_P: J_M2C3.47 (REFCLKp0), U301.78 (REFCLKO_P2)
/CARD3_RX_N: J_M2C3.43 (PERn0), U301.107 (PETN2)
/CARD3_RX_P: J_M2C3.41 (PERp0), U301.106 (PETP2)
/CARD3_TX_N: J_M2C3.37 (PETn0), U301.103 (PERN2)
/CARD3_TX_P: J_M2C3.35 (PETp0), U301.102 (PERP2)
/CC1_F1: J_FLASH1.A5 (CC1), R152.1
/CC1_F2: J_FLASH2.A5 (CC1), R252.1
/CC1_F3: J_FLASH3.A5 (CC1), R352.1
/CC2_F1: J_FLASH1.B5 (CC2), R153.1
/CC2_F2: J_FLASH2.B5 (CC2), R253.1
/CC2_F3: J_FLASH3.B5 (CC2), R353.1
/DEV_BST: C3.1, U25.6 (DEV_BST)
/DEV_SW: C3.2, L1.1, U25.5 (DEV_SW)
/E22_CT: C45.1, U21.3 (CT)
/E22_EN: U19.11 (E22_EN), U21.5 (EN/UVLO)
/E72_CT: C52.1, U22.3 (CT)
/E72_EN: U20.3 (E72_EN), U22.5 (EN/UVLO)
/EMCON_HW: J_AB1.15, J_PANEL.8, Q106.3 (D), Q206.3 (D), Q306.3 (D), R58.1, TP7.1, U19.1 (EMCON_HW), U19.9 (EMCON_HW), U19.12 (EMCON_HW), U20.1 (EMCON_HW), U41.33 (PC5), U51.33 (PC5), U61.33 (PC5)
/EN33_S1: R111.2, R112.1, U104.3 (EN33_S1), U105.2 (EN33_S1)
/EN33_S2: R211.2, R212.1, U204.3 (EN33_S2), U205.2 (EN33_S2)
/EN33_S3: R311.2, R312.1, U304.3 (EN33_S3), U305.2 (EN33_S3)
/ETH1_P0_N: C176.1, U30A.10 (Ethernet_Pair0_N)
/ETH1_P0_P: C175.1, U30A.12 (Ethernet_Pair0_P)
/ETH1_P1_N: C178.1, U30A.6 (Ethernet_Pair1_N)
/ETH1_P1_P: C177.1, U30A.4 (Ethernet_Pair1_P)
/ETH1_P2_N: C180.1, U30A.9 (Ethernet_Pair2_N)
/ETH1_P2_P: C179.1, U30A.11 (Ethernet_Pair2_P)
/ETH1_P3_N: C182.1, U30A.5 (Ethernet_Pair3_N)
/ETH1_P3_P: C181.1, U30A.3 (Ethernet_Pair3_P)
/ETH2_P0_N: C276.1, U31A.10 (Ethernet_Pair0_N)
/ETH2_P0_P: C275.1, U31A.12 (Ethernet_Pair0_P)
/ETH2_P1_N: C278.1, U31A.6 (Ethernet_Pair1_N)
/ETH2_P1_P: C277.1, U31A.4 (Ethernet_Pair1_P)
/ETH2_P2_N: C280.1, U31A.9 (Ethernet_Pair2_N)
/ETH2_P2_P: C279.1, U31A.11 (Ethernet_Pair2_P)
/ETH2_P3_N: C282.1, U31A.5 (Ethernet_Pair3_N)
/ETH2_P3_P: C281.1, U31A.3 (Ethernet_Pair3_P)
/ETH3_P0_N: C376.1, U32A.10 (Ethernet_Pair0_N)
/ETH3_P0_P: C375.1, U32A.12 (Ethernet_Pair0_P)
/ETH3_P1_N: C378.1, U32A.6 (Ethernet_Pair1_N)
/ETH3_P1_P: C377.1, U32A.4 (Ethernet_Pair1_P)
/ETH3_P2_N: C380.1, U32A.9 (Ethernet_Pair2_N)
/ETH3_P2_P: C379.1, U32A.11 (Ethernet_Pair2_P)
/ETH3_P3_N: C382.1, U32A.5 (Ethernet_Pair3_N)
/ETH3_P3_P: C381.1, U32A.3 (Ethernet_Pair3_P)
/EXP_INT: J_AB1.13, J_PANEL.6, R56.1, U1.94 (INTRP_N), U5.6 (INT), U6.1 (~INT), U7.1 (~INT), U9.3 (EXP_INT), U10.3 (EXP_INT)
/EXP_SPARE1: TP41.1, U7.9 (IO0_5)
/EXP_SPARE2: TP42.1, U7.10 (IO0_6)
/EXP_SPARE3: TP43.1, U7.11 (IO0_7)
/EXP_SPARE4: TP44.1, U7.13 (IO1_0)
/EXP_SPARE5: TP45.1, U7.14 (IO1_1)
/EXP_SPARE6: TP46.1, U7.15 (IO1_2)
/EXP_SPARE7: TP47.1, U7.16 (IO1_3)
/EXP_SPARE8: TP48.1, U7.17 (IO1_4)
/EXP_SPARE9: TP49.1, U7.18 (IO1_5)
/EXP_SPARE10: TP50.1, U7.19 (IO1_6)
/EXP_SPARE11: TP51.1, U7.20 (IO1_7)
/FAN_PWM1: J_FAN1.4, R151.1, U30A.19 (Fan_PWM)
/FAN_PWM2: J_FAN2.4, R251.1, U31A.19 (Fan_PWM)
/FAN_PWM3: J_FAN3.4, R351.1, U32A.19 (Fan_PWM)
/FAN_TACHO1: J_FAN1.3, U30A.16 (Fan_Tacho)
/FAN_TACHO2: J_FAN2.3, U31A.16 (Fan_Tacho)
/FAN_TACHO3: J_FAN3.3, U32A.16 (Fan_Tacho)
/GNSS_3V3: C43.1, C44.1, R24.2, U15.6 (VDD)
/GNSS_ANT: C42.1, J_GNSS1.1 (In), L3.2
/GNSS_BIAS: L3.1, R23.2
/GNSS_DM: U15.5 (D-), U202.2 (USB_DM_DN1)
/GNSS_DP: U15.4 (D+), U202.1 (USB_DP_DN1)
/GNSS_PPS: Q104.3 (D), Q204.3 (D), Q304.3 (D), R22.1, TP9.1, U11.3 (1PPS)
/GNSS_PPS_CM1: Q104.2 (S), R156.1, U30A.46 (GPIO22)
/GNSS_PPS_CM2: Q204.2 (S), R256.1, U31A.46 (GPIO22)
/GNSS_PPS_CM3: Q304.2 (S), R356.1, U32A.46 (GPIO22)
/GNSS_RF_IN: C42.2, U11.11 (RF_IN)
/GNSS_RST: R24.1, U15.9 (RSTb)
/GNSS_RST_n: R21.1, U11.8 (RESET_N)
/GNSS_RXD: U11.21 (RXD1), U15.26 (TXD)
/GNSS_RXD2: J_GNSS2.3, U11.7 (RXD2)
/GNSS_TXD: U11.20 (TXD1), U15.25 (RXD)
/GNSS_TXD2: J_GNSS2.2, U11.6 (TXD2)
/GNSS_VDD_RF: R23.1, U11.9 (VDD_RF)
/HB1: J_PANEL.18, Q105.3 (D), R158.1, U41.30 (PA6), U51.30 (PA6), U61.30 (PA6)
/HB2: J_PANEL.19, Q205.3 (D), R258.1, U41.31 (PA7), U51.31 (PA7), U61.31 (PA7)
/HB3: J_PANEL.20, Q305.3 (D), R358.1, U41.32 (PC4), U51.32 (PC4), U61.32 (PC4)
/HB_CM1: Q105.2 (S), R157.1, U30A.29 (GPIO16)
/HB_CM2: Q205.2 (S), R257.1, U31A.29 (GPIO16)
/HB_CM3: Q305.2 (S), R357.1, U32A.29 (GPIO16)
/HDMI1_CEC: U3.18 (CEC_A), U30B.151 (HDMI0_CEC)
/HDMI1_CK_N: U3.31 (D3N_A), U30B.190 (HDMI0_CLK_N)
/HDMI1_CK_P: U3.32 (D3P_A), U30B.188 (HDMI0_CLK_P)
/HDMI1_D0_N: U3.37 (D0N_A), U30B.184 (HDMI0_TX0_N)
/HDMI1_D0_P: U3.38 (D0P_A), U30B.182 (HDMI0_TX0_P)
/HDMI1_D1_N: U3.35 (D1N_A), U30B.178 (HDMI0_TX1_N)
/HDMI1_D1_P: U3.36 (D1P_A), U30B.176 (HDMI0_TX1_P)
/HDMI1_D2_N: U3.33 (D2N_A), U30B.172 (HDMI0_TX2_N)
/HDMI1_D2_P: U3.34 (D2P_A), U30B.170 (HDMI0_TX2_P)
/HDMI1_HPD: U3.19 (HPD_A), U30B.153 (HDMI0_HOTPLUG)
/HDMI1_SCL: U3.42 (SCL_A), U30B.200 (HDMI0_SCL)
/HDMI1_SDA: U3.41 (SDA_A), U30B.199 (HDMI0_SDA)
/HDMI2_CEC: U3.20 (CEC_B), U31B.151 (HDMI0_CEC)
/HDMI2_CK_N: U3.22 (D3N_B), U31B.190 (HDMI0_CLK_N)
/HDMI2_CK_P: U3.23 (D3P_B), U31B.188 (HDMI0_CLK_P)
/HDMI2_D0_N: U3.28 (D0N_B), U31B.184 (HDMI0_TX0_N)
/HDMI2_D0_P: U3.29 (D0P_B), U31B.182 (HDMI0_TX0_P)
/HDMI2_D1_N: U3.26 (D1N_B), U31B.178 (HDMI0_TX1_N)
/HDMI2_D1_P: U3.27 (D1P_B), U31B.176 (HDMI0_TX1_P)
/HDMI2_D2_N: U3.24 (D2N_B), U31B.172 (HDMI0_TX2_N)
/HDMI2_D2_P: U3.25 (D2P_B), U31B.170 (HDMI0_TX2_P)
/HDMI2_HPD: U3.21 (HPD_B), U31B.153 (HDMI0_HOTPLUG)
/HDMI2_SCL: U3.40 (SCL_B), U31B.200 (HDMI0_SCL)
/HDMI2_SDA: U3.39 (SDA_B), U31B.199 (HDMI0_SDA)
/HDMI3_CEC: U4.20 (CEC_B), U32B.151 (HDMI0_CEC)
/HDMI3_CK_N: U4.22 (D3N_B), U32B.190 (HDMI0_CLK_N)
/HDMI3_CK_P: U4.23 (D3P_B), U32B.188 (HDMI0_CLK_P)
/HDMI3_D0_N: U4.28 (D0N_B), U32B.184 (HDMI0_TX0_N)
/HDMI3_D0_P: U4.29 (D0P_B), U32B.182 (HDMI0_TX0_P)
/HDMI3_D1_N: U4.26 (D1N_B), U32B.178 (HDMI0_TX1_N)
/HDMI3_D1_P: U4.27 (D1P_B), U32B.176 (HDMI0_TX1_P)
/HDMI3_D2_N: U4.24 (D2N_B), U32B.172 (HDMI0_TX2_N)
/HDMI3_D2_P: U4.25 (D2P_B), U32B.170 (HDMI0_TX2_P)
/HDMI3_HPD: U4.21 (HPD_B), U32B.153 (HDMI0_HOTPLUG)
/HDMI3_SCL: U4.40 (SCL_B), U32B.200 (HDMI0_SCL)
/HDMI3_SDA: U4.39 (SDA_B), U32B.199 (HDMI0_SDA)
/HDMIM_CEC: U3.15 (CEC), U4.18 (CEC_A)
/HDMIM_CK_N: U3.13 (D3N), U4.31 (D3N_A)
/HDMIM_CK_P: U3.12 (D3P), U4.32 (D3P_A)
/HDMIM_D0_N: U3.6 (D0N), U4.37 (D0N_A)
/HDMIM_D0_P: U3.5 (D0P), U4.38 (D0P_A)
/HDMIM_D1_N: U3.8 (D1N), U4.35 (D1N_A)
/HDMIM_D1_P: U3.7 (D1P), U4.36 (D1P_A)
/HDMIM_D2_N: U3.11 (D2N), U4.33 (D2N_A)
/HDMIM_D2_P: U3.10 (D2P), U4.34 (D2P_A)
/HDMIM_HPD: U3.14 (HPD), U4.19 (HPD_A)
/HDMIM_SCL: U3.3 (SCL), U4.42 (SCL_A)
/HDMIM_SDA: U3.4 (SDA), U4.41 (SDA_A)
/HDMIO_CEC: J_HDMI.13 (CEC), U4.15 (CEC)
/HDMIO_CK_N: J_HDMI.12 (CK-), U4.13 (D3N)
/HDMIO_CK_P: J_HDMI.10 (CK+), U4.12 (D3P)
/HDMIO_D0_N: J_HDMI.9 (D0-), U4.6 (D0N)
/HDMIO_D0_P: J_HDMI.7 (D0+), U4.5 (D0P)
/HDMIO_D1_N: J_HDMI.6 (D1-), U4.8 (D1N)
/HDMIO_D1_P: J_HDMI.4 (D1+), U4.7 (D1P)
/HDMIO_D2_N: J_HDMI.3 (D2-), U4.11 (D2N)
/HDMIO_D2_P: J_HDMI.1 (D2+), U4.10 (D2P)
/HDMIO_HPD: R19.2, R20.1, U4.14 (HPD)
/HDMIO_HPD_IN: J_HDMI.19 (HPD), R19.1
/HDMIO_SCL: J_HDMI.15 (SCL), R17.1, U4.3 (SCL)
/HDMIO_SDA: J_HDMI.16 (SDA), R18.1, U4.4 (SDA)
/HDMI_SEL1: J_PANEL.12, R15.1, TP18.1, U3.17 (SEL2)
/HDMI_SEL2: J_PANEL.13, R16.1, TP19.1, U4.17 (SEL2)
/HDMI_SW_EN: R14.1, U3.2 (EN), U3.16 (SEL1), U4.2 (EN), U4.16 (SEL1)
/HOST1_0D_N: U30B.136 (USB3-0-DM), U110.2 (1Dn)
/HOST1_0D_P: U30B.134 (USB3-0-DP), U110.1 (1Dp)
/HOST1_0RX_N: U30B.128 (USB3-0-RX_N), U109.16 (B1n)
/HOST1_0RX_P: U30B.130 (USB3-0-RX_P), U109.17 (B1p)
/HOST1_0TX_N: U30B.140 (USB3-0-TX_N), U109.18 (B0n)
/HOST1_0TX_P: U30B.142 (USB3-0-TX_P), U109.19 (B0p)
/HOST1_1D_N: U30B.165 (USB3-1-DM), U310.4 (2Dn)
/HOST1_1D_P: U30B.163 (USB3-1-DP), U310.3 (2Dp)
/HOST1_1RX_N: U30B.157 (USB3-1-RX_N), U309.12 (C1n)
/HOST1_1RX_P: U30B.159 (USB3-1-RX_P), U309.13 (C1p)
/HOST1_1TX_N: U30B.169 (USB3-1-TX_N), U309.14 (C0n)
/HOST1_1TX_P: U30B.171 (USB3-1-TX_P), U309.15 (C0p)
/HOST2_0D_N: U31B.136 (USB3-0-DM), U210.2 (1Dn)
/HOST2_0D_P: U31B.134 (USB3-0-DP), U210.1 (1Dp)
/HOST2_0RX_N: U31B.128 (USB3-0-RX_N), U209.16 (B1n)
/HOST2_0RX_P: U31B.130 (USB3-0-RX_P), U209.17 (B1p)
/HOST2_0TX_N: U31B.140 (USB3-0-TX_N), U209.18 (B0n)
/HOST2_0TX_P: U31B.142 (USB3-0-TX_P), U209.19 (B0p)
/HOST2_1D_N: U31B.165 (USB3-1-DM), U110.4 (2Dn)
/HOST2_1D_P: U31B.163 (USB3-1-DP), U110.3 (2Dp)
/HOST2_1RX_N: U31B.157 (USB3-1-RX_N), U109.12 (C1n)
/HOST2_1RX_P: U31B.159 (USB3-1-RX_P), U109.13 (C1p)
/HOST2_1TX_N: U31B.169 (USB3-1-TX_N), U109.14 (C0n)
/HOST2_1TX_P: U31B.171 (USB3-1-TX_P), U109.15 (C0p)
/HOST3_0D_N: U32B.136 (USB3-0-DM), U310.2 (1Dn)
/HOST3_0D_P: U32B.134 (USB3-0-DP), U310.1 (1Dp)
/HOST3_0RX_N: U32B.128 (USB3-0-RX_N), U309.16 (B1n)
/HOST3_0RX_P: U32B.130 (USB3-0-RX_P), U309.17 (B1p)
/HOST3_0TX_N: U32B.140 (USB3-0-TX_N), U309.18 (B0n)
/HOST3_0TX_P: U32B.142 (USB3-0-TX_P), U309.19 (B0p)
/HOST3_1D_N: U32B.165 (USB3-1-DM), U210.4 (2Dn)
/HOST3_1D_P: U32B.163 (USB3-1-DP), U210.3 (2Dp)
/HOST3_1RX_N: U32B.157 (USB3-1-RX_N), U209.12 (C1n)
/HOST3_1RX_P: U32B.159 (USB3-1-RX_P), U209.13 (C1p)
/HOST3_1TX_N: U32B.169 (USB3-1-TX_N), U209.14 (C0n)
/HOST3_1TX_P: U32B.171 (USB3-1-TX_P), U209.15 (C0p)
/HUB1_D1TX_N: C162.1, U102.4 (USB_SSTXM_DN1)
/HUB1_D1TX_P: C161.1, U102.3 (USB_SSTXP_DN1)
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
Notes on the sheet:
PCB-B COMPUTE B21
SHARED POWER
SHARED POWER: DEVICE RAIL, +3V3_DEV, KSZ CORE RAILS, CR2032
page 1 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
JST-VH socket
AP63203WU-7 3.3 V 2 A buck
4.7uH
TPS62933DRLR buck 1.2 V Ethernet s..
2.2uH
AP2112K-2.5 LDO
CR2032 holder Keystone 3034
p7,15,22,30,..
p31
p9,17,24,27
p25,26,31,32,..
p26
p26,31
SLOT S1
SLOT S1: COMPUTE MODULE 5, PCIe SWITCH, USB 3 HUB, M.2 SOCKETS, RAILS, SUPPORT
page 2 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
Amphenol 10164227-1004A1RLF recept..
green ACT
decoupling of U30A
SMBJ6.0A
p25
SLOT S1: COMPUTE MODULE 5, PCIe SWITCH, USB 3 HUB, M.2 SOCKETS, RAILS, SUPPORT (continued)
page 3 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
AP64500SP-13 5 A buck
68k
22u 10V
p6,7
page 4 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
TPS62933DRLR buck 1.0 V PCIe switc..
TPS62933DRLR buck 1.1 V hub core S1
page 5 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
Diodes PI7C9X2G404SL PCIe 2.0 switch
green NVMe link
green card link
475 1%
1.43k 1%

Notices in the files:
v2/ecad/pcb-b-compute-b19/pcb-b-compute.kicad_sch:
page 6 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
page 7 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
page 8 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
page 9 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
page 10 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
page 11 of 37 MeshSat field kit V2, CERN-OHL-S-2.0 PROTOTYPE, nothing built 2026-09-17
